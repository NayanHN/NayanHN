FILESEXTRAPATHS_prepend := "${THISDIR}:"

INTREE_DEFCONFIG = "imx6_Rb_defconfig"
COMPATIBLE_MACHINE = "ruggedboard-imx6ul"

SRC_URI += "file:// \
	
"
