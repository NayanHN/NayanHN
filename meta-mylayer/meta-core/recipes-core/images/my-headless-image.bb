SUMMARY = "image"
DESCRIPTION = "about image"
LICENSE = "MIT"

inherit core-image

IMAGE_ROOTFS_SIZE ?= "8192"

IMAGE_INSTALL = " \
    
    "
